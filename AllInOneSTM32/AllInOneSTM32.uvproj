# Keil uVision project AllInOneSTM32.uvproj, settings and files
target AllInOneSTM32 (ARM-ADS)
  device: STM32F100C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: AllInOneSTM32 +hex
  AfterMake: .\Tool\HEX2BIN.exe .\Output\AllInOneSTM32.hex
  c flags: Optim=4 OneElfS=1
  c define: STM32F10X_MD_VL,USE_STDPERIPH_DRIVER
  c include: .\Core;.\Stm32_lib\inc;.\Usr\inc
  memory RVCT4: ROM 0x8004000 size 0xc000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Usr
    ./Usr/src/: main.c Retarget.c system_check.c system_clock.c uart.c system_tick.c test_led_lamp.c module_nibp.c system_adc.c system_nvic.c module_ecg.c i2c_int.c i2c_packet.c power.c watchdog.c
  group Core
    ./Core/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md_vl.s
  group Stmlib
    ./Stm32_lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_it.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
