# Keil uVision project aio_stm_iap.uvproj, settings and files
target aio_stm_iap (ARM-ADS)
  device: STM32F100C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: aio_stm_iap +hex
  AfterMake: .\Binary\hex2bin.exe .\output\aio_stm_iap.hex
  c flags: Optim=4 OneElfS=1
  c define: STM32F10X_MD_VL, USE_STDPERIPH_DRIVER
  c include: .\IAP\inc;.\lib\st_lib\inc;.\lib\CMSIS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group src
    ./IAP/src/: main.c config.c commands.c stm32f10x_it.c system_tick.c watchdog.c
  group inc
    ./IAP/inc/: commands.h config.h main.h stm32f10x_it.h includes.h system_tick.h watchdog.h
  group lib
    ./lib/st_lib/inc/: stm32f10x_conf.h misc.h stm32f10x_flash.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_rcc.h stm32f10x_bkp.h stm32f10x_usart.h
    ./lib/st_lib/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_bkp.c stm32f10x_usart.c
  group core
    ./lib/startup/: startup_stm32f10x_md_vl.s
    ./lib/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.h system_stm32f10x.c
  group doc
    ./: readme.txt
